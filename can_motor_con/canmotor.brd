# Repository Hikaru-Su/can_motor_con

File README.md:

# can_motor_con
1. A3921のMDを4つ、A3930のMDを2つ繋げられる。 
2. A3930はpwm周波数を30KHz以上にしてください。
3. resetは基板上のスイッチで行う。A3921とA3930で分けてある。

## EAGLE design can_motor_con/canmotor.brd

Parts:
BOX10P-L2: BOX10PBOX10P-L; BOX10P-L
C1, C2, C4, C9, C12, C13: 0.1u; C1608
C3: 0.22u; C2012
C5, C10: 4.7u; C2012
C6: 470p; C1608
C7: 10u; C2012
C8: 1u; C1608
C11: C-EUC1608; C1608
LED1, LED2: 1608LED; 1608
OSC1: 12M; CSTNE#
R1: 33k; 1608
R2: 20k; 1608
R3, R4, R6, R7: 10k; 1608
R5: 120; 1608
R8, R9: 1k; 1608
U$1: STM32F303K_32LQFP; LQFP32-7X7
U$2: NJM11100; SOT23-6
U$3: 2SC5964; PCP
U$4, U$13, U$14: TAKUTOSUITTI2
U$5: MCP2562MCP2561-SN; SOIC8
U$6: BOX14P; CON_HEDA14P_1.27
U$7, U$12: DF1B_L_6P
U$8, U$9, U$10, U$11: DF1B_L_4P

Connections:
BL_DIR1: U$1.18 (PIN18), U$7.PIN4
BL_DIR2: U$1.20 (PIN20), U$12.PIN4
CAN_H: BOX10P-L2.P$5, R5.2, U$5.P$7 (CANH)
CAN_L: BOX10P-L2.P$6, R5.1, U$5.P$6 (CANL)
CAN_RX: U$1.21 (PIN21), U$5.P$4 (RXD)
CAN_TX: U$1.22 (PIN22), U$5.P$1 (TXD)
COAST1: U$1.19 (PIN19), U$7.PIN3
COAST2: U$1.27 (PIN27), U$12.PIN3
DIR1: U$1.11 (PIN11), U$8.PIN1
DIR2: U$1.13 (PIN13), U$9.PIN1
DIR3: U$1.14 (PIN14), U$10.PIN1
DIR4: U$1.15 (PIN15), U$11.PIN1
GND: BOX10P-L2.P$7, BOX10P-L2.P$8, C1.1, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, LED1.K, LED2.K, OSC1.P$2, R2.1, R3.2, R4.2, U$1.16 (PIN16_VSS), U$1.32 (PIN32_VSS), U$2.2 (PIN2_GND), U$4.P$2 (PIN2), U$5.P$2 (VSS), U$6.5, U$6.7, U$6.11, U$7.PIN6, U$8.PIN4, U$9.PIN4, U$10.PIN4, U$11.PIN4, U$12.PIN6, U$13.P$1 (PIN1), U$14.P$1 (PIN1)
JTCK: U$1.24 (PIN24), U$6.6
JTDI: U$1.25 (PIN25), U$6.10
JTDO: U$1.26 (PIN26), U$6.8
JTMS: U$1.23 (PIN23), U$6.4
unnamed: C6.2, R1.1, R2.2, U$2.5 (PIN5_VADJ)
unnamed: C4.1, U$2.3 (PIN3_NOIS?)
unnamed: C5.1, C6.1, U$2.4 (PIN4_VOUT), U$3.1 (B)
unnamed: OSC1.P$1 (IN), U$1.3 (PIN3_OSCOUT)
unnamed: OSC1.P$3 (OUT), U$1.2 (PIN2_OSCIN)
unnamed: R3.1, U$1.31 (PIN31_BOOT0)
unnamed: C12.2, R7.1, U$8.PIN3, U$9.PIN3, U$10.PIN3, U$11.PIN3, U$14.P$2 (PIN2)
unnamed: R4.1, U$5.P$8 (STBY)
unnamed: C13.2, R6.1, U$7.PIN1, U$12.PIN1, U$13.P$2 (PIN2)
unnamed: LED1.A, R8.1
unnamed: LED2.A, R9.1
unnamed: R8.2, U$1.28 (PIN28)
NRST: C9.1, U$1.4 (PIN4_NRST), U$4.P$1 (PIN1), U$6.12
TIM2_CH1: U$1.6 (PIN6), U$8.PIN2
TIM2_CH2: U$1.7 (PIN7), U$9.PIN2
TIM2_CH3: U$1.8 (PIN8), U$10.PIN2
TIM2_CH4: U$1.9 (PIN9), U$11.PIN2
TIM3_CH1: U$1.12 (PIN12), U$7.PIN5
TIM3_CH2: U$1.10 (PIN10), U$12.PIN5
V3.3: C1.2, C2.1, C7.1, C8.1, C10.1, R1.2, R6.2, R7.2, R9.2, U$1.1 (PIN1_VDD), U$1.5 (PIN5_VDDA), U$1.17 (PIN17_VDD), U$3.3 (E), U$5.P$5 (VIO), U$6.3
V12: BOX10P-L2.P$1, BOX10P-L2.P$2
VCC: BOX10P-L2.P$9, BOX10P-L2.P$10, C3.1, C11.2, U$2.1 (PIN1_CON), U$2.6 (PIN6_VIN), U$3.2 (C), U$3.2@2 (C), U$5.P$3 (VDD)
VCP_RX: U$1.30 (PIN30), U$6.13
VCP_TX: U$1.29 (PIN29), U$6.14

Notes on the sheet:
4pinがブラシ付きモータ、6pinがブラシレスモータ
ブラシレスのPWM周波数は30KHz以上でお願いします

Board: 2 copper layers, 50.8 x 50.8 mm, 40 parts (17 on the bottom side), 41 nets.

## Commit log

2020-10-23 pwm入力によるMDをcanバスにつなぐ基板
2020-10-23 ledをついか
2021-11-09 mcp2562スタンバイピンプルダウン
